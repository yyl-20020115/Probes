# Keil uVision project LED test.uvproj, settings and files
target Capture (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Capture +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CORE;..\LIB\inc;..\HARDWARE\delay;..\HARDWARE\LED;..\HARDWARE\SYS;..\HARDWARE\usart;..\USER;..\USMART;..\HARDWARE\RTC;..\HARDWARE\DataScop;..\HARDWARE\DMA;..\HARDWARE\eMPL;..\HARDWARE\I2C;..\HARDWARE\nRF905;..\HARDWARE\TIMER;..\HARDWARE\AK8975;..\HARDWARE\mpu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SYS/: sys.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/I2C/: STM32_I2C.c
    ../HARDWARE/TIMER/: Time.c
    ../HARDWARE/mpu/: mpu.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
