# Keil uVision project test.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY,USE_STM324xG_EVAL,STM32F40XX
  c include: ..\inc;..\board\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Third_Party\fat_fs\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\Third_Party\lwip_v1.3.2\src\include\lwip;..\Third_Party\lwip_v1.3.2\src\include\netif;..\Third_Party\lwip_v1.3.2\src\include\ipv4;..\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Third_Party\lwip_v1.3.2\src\include;..\Third_Party\lwip_v1.3.2\port\STM32F4x7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c serial_debug.c ADS1256.c
  group board
    ../board/src/: led.c key.c delay.c lcd.c usart.c rtc.c touch.c spi.c
  group periph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_sdio.c stm32f4xx_tim.c
